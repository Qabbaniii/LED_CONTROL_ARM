# Keil uVision project TASK1 LED.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TASK1 LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c include: .\COTS\MCAL\GPT;.\COTS\MCAL\DIO;.\COTS\MCAL\INT;.\COTS\SERVICES;.\COTS\HAL\LED
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./COTS/APP/: main.c
  group DIO
    ./COTS/MCAL/DIO/: DIO_interface.h DIO_register.h DIO_Program.c
  group INT
    ./COTS/MCAL/INT/: INT_register.h INT_Program.c INT_interface.h
  group GPT
    ./COTS/MCAL/GPT/: GPT_interface.h GPT_Program.c GPT_register.h
  group SERVIESES
    ./COTS/SERVICES/: Std_Types.h Bit_Math.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
